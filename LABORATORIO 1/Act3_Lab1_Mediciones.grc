options:
  parameters:
    generate_options: qt_gui
    id: Act3_Lab1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRx
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la portadora
    start: 50e6
    step: 1e5
    stop: 250e6
    value: 90.7e6
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de corte del filtro
    start: 10e3
    step: 1e2
    stop: 100e3
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk (gr.sync_block ):\n\n\tdef __init__ ( self ) : # only default arguments here\n\t\tgr.sync_block . __init__ (\n\t\t\tself ,\n\t\t\tname = 'Promedios_de_tiempos', # will show up in GRC\n\t\t\tin_sig =[ np.float32 ],\n\t\t\tout_sig =[ np.float32 ,np.float32 ,np.float32 ,np.float32 ,np.float32 ]\n\t\t)\n\t\tself.acum_anterior = 0\n\t\tself.Ntotales = 0\n\t\tself.acum_anterior1 = 0\n\t\tself.acum_anterior2 = 0\n\n\tdef work (self, input_items , output_items ):\n\t\tx = input_items [0] # Senial de entrada .\n\t\ty0 = output_items [0] # Promedio de la senial\n\t\ty1 = output_items [1] # Media cuadratica de la senial\n\t\ty2 = output_items [2] # RMS de la senial\n\t\ty3 = output_items [3] # Potencia promedio de la senial\n\t\ty4 = output_items [4] # Desviacion estandar de la senial\n\t\n\t\t# Calculo del promedio\n\t\tN = len(x)\n\t\tself.Ntotales = self.Ntotales + N\n\t\tacumulado = self.acum_anterior + np.cumsum(x)\n\t\tself.acum_anterior = acumulado[N -1]\n\t\ty0[:]= acumulado/self.Ntotales\n\t\n\t\t# Calculo de la media cuadratica\n\t\tx2=np.multiply(x,x)\n\t\tacumulado1 = self.acum_anterior1 + np.cumsum(x2)\n\t\tself.acum_anterior1 = acumulado1[N -1]\n\t\ty1[:] = acumulado1/self.Ntotales\n\n\t\t# Calculo de la RMS\n\t\ty2[:] = np.sqrt(y1)\n\t\n\t\t# Calculo de la potencia promedio\n\t\ty3[:] = np.multiply(y2 ,y2)\n\n\t\t# Calculo de la desviacion estandar\n\t\tx3 = np.multiply(x-y0 ,x-y0)\n\t\tacumulado2 = self.acum_anterior2 + np.cumsum(x3)\n\t\tself.acum_anterior2 = acumulado2[N -1]\n\t\ty4[:] = np.sqrt(acumulado2/self.Ntotales)\n\t\n\t\treturn len (x)\n\t\t\n\t\t\n\t\t\n\t\t\n\t\n\t\n\t\n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/25
    fc: '0'
    fftsize: '8192'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: '0'
    fftsize: '8192'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media Cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia Promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviacion Estadar"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRx
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_2, '0']
- [epy_block_0, '1', qtgui_number_sink_0, '0']
- [epy_block_0, '2', qtgui_number_sink_0_0, '0']
- [epy_block_0, '3', qtgui_number_sink_0_1, '0']
- [epy_block_0, '4', qtgui_number_sink_0_3, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
